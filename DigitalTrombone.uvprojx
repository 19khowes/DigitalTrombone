# Keil uVision project DigitalTrombone.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: DigitalTrombone
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6314W
  group Source Group 1
    ./: main.c startup_stm32l476xx.s stm32l476xx.h USART.c USART.h buzzer.c buzzer.h keypad.c keypad.h ultrasonic.c ultrasonic.h
software components: CMSIS:CORE 5.6.0
